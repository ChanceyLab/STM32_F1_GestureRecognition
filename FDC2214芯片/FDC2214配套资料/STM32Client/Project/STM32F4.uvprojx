# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\User;..\System;..\MPU6050;..\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group System
    ../System/: delay.c
  group Oled
    ../oled/: oled.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_i2c.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_iwdg.c
software components: CMSIS:CORE 5.1.1
